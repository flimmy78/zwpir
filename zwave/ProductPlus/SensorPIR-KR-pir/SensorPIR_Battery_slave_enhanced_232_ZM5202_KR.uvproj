# Keil uVision project SensorPIR_Battery_slave_enhanced_232_ZM5202_KR.uvproj, settings and files
target SensorPIR_Battery_slave_enhanced_232_ZM5202_KR (MCS-51)
  device: ZW0301 Zensys
  cpu: IRAM(0-0x7F) XRAM(0-0x7FF) IROM(0-0x7FFF) CLOCK(32000000)
  output: SensorPIR_Battery_slave_enhanced_232_ZM5202_KR.aof +hex
  AfterMake: cmd /c %%TOOLSDIR%%\uVisionProjectGenerator\MakePatch.bat ZW050X APP SensorPIR_Battery_slave_enhanced_232_ZM5202_KR
  c flags: Optimize=12
  c define: ZW_SLAVE, ZW_SLAVE_32, ZW_SLAVE_ENHANCED_232, ZW_SLAVE_ROUTING, ZW050x, ZW0501, NEW_NODEINFO, ZW_SELF_HEAL , ZW_3CH_SYSTEM , BANKING, KR , BATTERY, ZM5202
  c misc: DB OE NOCO SB LC CD
  c include: ..\..\Z-WAVE\INCLUDE;..\..\Z-WAVE\IO_DEFINES;.\BUILD_PRJ;.\BUILD_PRJ\SENSORPIR_BATTERY_SLAVE_ENHANCED_232_ZM5202_KR\RELS;.\BUILD_PRJ\SENSORPIR_BATTERY_SLAVE_ENHANCED_232_ZM5202_KR;C:\KEIL_V5\C51\INC;..\APPLICATIONUTILITIES;..\APPLICATIONCOMMANDHANDLERS;..\..\ZLIB\CMDCLASS;..\..\ZLIB\DEVTYPES;..\..\ZLIB\HANDLER
  asm include: as above
  link misc: NOOVERLAY
  group Z-Wave Lib (COMMON forced)
    ../../Z-WAVE/LIB/EXT_NVM/: ZW_GENERIC_P0_4_SPI1_IF.OBJ
    ../../Z-WAVE/LIB/SLAVE_ENHANCED_232_ZW050X_3CH/: ZW_SLAVE_ENHANCED_232_ZW050X_3CH.LIB
  group Z-Wave Lib (BANK1 forced)
    ../../Z-WAVE/LIB/SLAVE_ENHANCED_232_ZW050X_3CH/: ZW_SLAVE_ENHANCED_232_ZW050X_3CH.LIB
  group Z-Wave Lib (BANK3 forced)
    ../../Z-WAVE/LIB/SLAVE_ENHANCED_232_ZW050X_3CH/: ZW_SLAVE_ENHANCED_232_ZW050X_3CH.LIB
  group Appl Source Code (BANK2)
    ./: SensorPIR.c eeprom.c
    ../APPLICATIONUTILITIES/: ZW_NVR_APP_API.C MANUFACTURER_SPECIFIC_DEVICE_ID.C EVENT_UTIL.C KEYMAN.C P_BUTTON.C ONE_BUTTON.C ZW_STRING.C SLAVE_LEARN_PLUS.C ASSOCIATION_PLUS.C AGI.C NOTIFICATION.C BATTERY_MONITOR.C BATTERY_NON_ZERO_VARS.C BATTERY_PLUS.C ZW_TRANSPORTNATIVE.C
    ../APPLICATIONCOMMANDHANDLERS/: ZW_TX_MUTEX.C COMMANDCLASSVERSION.C COMMANDCLASSPOWERLEVEL.C COMMANDCLASSDEVICERESETLOCALLY.C COMMANDCLASSASSOCIATION.C COMMANDCLASSASSOCIATIONGROUPINFO.C COMMANDCLASSMANUFACTURERSPECIFIC.C COMMANDCLASSZWAVEPLUSINFO.C COMMANDCLASSBASIC.C COMMANDCLASSBATTERY.C COMMANDCLASSNOTIFICATION.C COMMANDCLASSWAKEUP.C
  group Appl Source Code (COMMON)
    ../../Z-WAVE/IO_DEFINES/: ZW_L51_BANK.A51 APP_RFSETUP.C ZW_APP_VERSION.A51
    ../APPLICATIONUTILITIES/: ZW_FIRMWARE_DESCRIPTOR_ADDR.C ZW_FIRMWARE_DESCRIPTOR.C
  group Z-Wave Lib (COMMON)
    ../../Z-WAVE/LIB/SLAVE_ENHANCED_232_ZW050X_3CH/: ZW_SLAVE_ENHANCED_232_ZW050X_3CH.LIB
    C:/KEIL_V5/C51//LIB/: C51FPL.LIB C51L.LIB
    ../../Z-WAVE/LIB/INIT_VARS/: INIT_VARS.OBJ
    ../../Z-WAVE/LIB/RF_FREQ/: ZW_RF_050X_KR.OBJ
  group Z-Wave Inc
    ../APPLICATIONUTILITIES/: AGI.H ZW_PRODUCT_ID_ENUM.H ZW_STRING.H ASSOCIATION_PLUS.H EVENT_UTIL.H ZW_TRANSPORTLAYER.H ZW_TRANSPORTNATIVE.H MANUFACTURER_SPECIFIC_DEVICE_ID.H BATTERY_PLUS.H BATTERY_MONITOR.H MISC.H ZW_NVR_APP_API.H KEYMAN.H EV_MAN.H ONE_BUTTON.H P_BUTTON.H NOTIFICATION.H SLAVE_LEARN.H
    ../../Z-WAVE/INCLUDE/: ZW_TYPEDEFS.H ZW_SYSDEFS.H ZW0X0X.H ZW050X.H ZW_CLASSCMD.H ZW_MEM_API.H ZW_UART_API.H ZW_RF040X.H ZW_BASIS_API.H ZW_TRANSPORT_API.H ZW_SECURITY_API.H ZW_TIMER_API.H ZW_SLAVE_32_API.H ZW_SLAVE_ROUTING_API.H ZW_SLAVE_API.H ZW_NODEMASK_API.H ZW_ADCDRIV_API.H ZW_NON_ZERO.H ZW_POWER_API.H ZW_STDINT.H ZW_NVM_DESCRIPTOR.H ZW_NVR_API.H ZW_FIRMWARE_BOOTLOADER_DEFS.H ZW_NVM_EXT_API.H ZW_FIRMWARE_DESCRIPTOR.H ZW_FLASH_API.H
    ./: CONFIG_APP.H EEPROM.H
    ../APPLICATIONCOMMANDHANDLERS/: COMMANDCLASSMANUFACTURERSPECIFIC.H ZW_TX_MUTEX.H COMMANDCLASSASSOCIATION.H COMMANDCLASSWAKEUP.H COMMANDCLASSBATTERY.H COMMANDCLASSPOWERLEVEL.H COMMANDCLASSASSOCIATIONGROUPINFO.H COMMANDCLASSBASIC.H COMMANDCLASSDEVICERESETLOCALLY.H COMMANDCLASSNOTIFICATION.H COMMANDCLASSVERSION.H COMMANDCLASSZWAVEPLUSINFO.H ZW_PLUS_VERSION.H
    ../../Z-WAVE/IO_DEFINES/: ZW_PINDEFS.H ZW_EVALDEFS.H
    C:/KEIL_V5/C51/INC/: STRING.H
