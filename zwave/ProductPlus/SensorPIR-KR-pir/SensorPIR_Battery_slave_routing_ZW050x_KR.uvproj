# Keil uVision project SensorPIR_Battery_slave_routing_ZW050x_KR.uvproj, settings and files
target SensorPIR_Battery_slave_routing_ZW050x_KR (MCS-51)
  device: ZW0301 Zensys
  cpu: IRAM(0-0x7F) XRAM(0-0x7FF) IROM(0-0x7FFF) CLOCK(32000000)
  output: SensorPIR_Battery_slave_routing_ZW050x_KR.aof +hex
  AfterMake: cmd /c %%TOOLSDIR%%\uVisionProjectGenerator\MakePatch.bat ZW050X APP SensorPIR_Battery_slave_routing_ZW050x_KR
  c flags: Optimize=12
  c define: slave_routing , KR , ZW_SECURITY_PROTOCOL , ZW_SECURITY_PROTOCOL_SINGLE_NETWORK_KEY , ZW_SLAVE, ZW_SLAVE_ROUTING, ZW050x, ZW0501, NEW_NODEINFO , ZW_3CH_SYSTEM , BANKING , BATTERY
  c misc: DB OE NOCO SB LC CD
  c include: ..\..\Z-WAVE\INCLUDE;..\..\Z-WAVE\IO_DEFINES;.\BUILD_PRJ;.\BUILD_PRJ\SENSORPIR_BATTERY_SLAVE_ROUTING_ZW050X_KR\RELS;.\BUILD_PRJ\SENSORPIR_BATTERY_SLAVE_ROUTING_ZW050X_KR;C:\KEIL_V5\C51\INC;..\APPLICATIONUTILITIES;..\APPLICATIONCOMMANDHANDLERS;..\..\ZLIB\CMDCLASS;..\..\ZLIB\DEVTYPES;..\..\ZLIB\HANDLER
  asm include: as above
  link misc: NOOVERLAY
  group Z-Wave Lib (COMMON forced)
    ../../Z-WAVE/LIB/LIBS2/: LIBS2_SLAVE.LIB
    ../../Z-WAVE/LIB/SLAVE_ROUTING_ZW050X_3CH/: ZW_SLAVE_ROUTING_ZW050X_3CH.LIB
  group Z-Wave Lib (BANK1 forced)
    ../../Z-WAVE/LIB/SLAVE_ROUTING_ZW050X_3CH/: ZW_SLAVE_ROUTING_ZW050X_3CH.LIB
    ../../Z-WAVE/LIB/LIBS2/: LIBS2CRYPTO.LIB
  group Z-Wave Lib (BANK3 forced)
    ../../Z-WAVE/LIB/SLAVE_ROUTING_ZW050X_3CH/: ZW_SLAVE_ROUTING_ZW050X_3CH.LIB
    ../../Z-WAVE/LIB/LIBS2/: LIBS2_SLAVE.LIB LIBS2CRYPTO.LIB
  group Appl Source Code (BANK2)
    ./: SensorPIR.c eeprom.c
    ../APPLICATIONUTILITIES/: ZW_NVR_APP_API.C IO_ZDP03A.C KEY_DRIVER.C GPIO_DRIVER.C ZW_STRING.C SLAVE_LEARN_PLUS.C ASSOCIATION_PLUS.C AGI.C ZW_TASK.C ZW_UTIL_QUEUE.C EV_MAN.C NOTIFICATION.C BATTERY_MONITOR.C BATTERY_NON_ZERO_VARS.C BATTERY_PLUS.C ZW_TRANSPORTMULTICAST.C ZW_TRANSPORTENDPOINT.C ZW_TRANSPORTSECPROTOCOL.C ZW_CMD_CLASS_LIST.C ENDPOINT_LOOKUP.C
    ../APPLICATIONCOMMANDHANDLERS/: COMMANDCLASS.C COMMANDCLASSVERSION.C COMMANDCLASSPOWERLEVEL.C COMMANDCLASSDEVICERESETLOCALLY.C COMMANDCLASSASSOCIATION.C COMMANDCLASSASSOCIATIONGROUPINFO.C COMMANDCLASSMANUFACTURERSPECIFIC.C COMMANDCLASSZWAVEPLUSINFO.C COMMANDCLASSBASIC.C COMMANDCLASSBASICCONTROLLER.C COMMANDCLASSBATTERY.C COMMANDCLASSNOTIFICATION.C COMMANDCLASSWAKEUP.C ZW_TX_MUTEX.C COMMANDCLASSMULTICHAN.C COMMANDCLASSMULTICHANASSOCIATION.C COMMANDCLASSSUPERVISION.C
  group Appl Source Code (COMMON)
    ../APPLICATIONUTILITIES/: INTERRUPT_DRIVER.C ZW_FIRMWARE_DESCRIPTOR_ADDR.C ZW_FIRMWARE_DESCRIPTOR.C
    ../../Z-WAVE/IO_DEFINES/: ZW_L51_BANK.A51 APP_RFSETUP.C ZW_APP_VERSION.A51
  group Z-Wave Lib (COMMON)
    ../../Z-WAVE/LIB/SLAVE_ROUTING_ZW050X_3CH/: ZW_SLAVE_ROUTING_ZW050X_3CH.LIB
    C:/KEIL_V5/C51//LIB/: C51FPL.LIB C51L.LIB
    ../../Z-WAVE/LIB/INIT_VARS/: INIT_VARS.OBJ
    ../../Z-WAVE/LIB/RF_FREQ/: ZW_RF_050X_KR.OBJ
