# IAR project Demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L101K3T STM8L101K3T
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ; STM8L10x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Demo.srec
  ILINK.IlinkOutputFile: Demo.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group StdPeriph_Driver
    STM8L10x_StdPeriph_Driver/src/: stm8l10x_awu.c stm8l10x_clk.c stm8l10x_exti.c stm8l10x_gpio.c stm8l10x_tim2.c stm8l10x_usart.c
  group User
    ./: main.c stm8l10x_conf.h stm8l10x_it.c stm8l10x_it.h
    STM8L10x_StdPeriph_Driver/inc/: stm8l10x.h
