<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\STM8L10x_StdPeriph_Driver\src\stm8l10x_awu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L10x_StdPeriph_Driver\src\stm8l10x_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L10x_StdPeriph_Driver\src\stm8l10x_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L10x_StdPeriph_Driver\src\stm8l10x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L10x_StdPeriph_Driver\src\stm8l10x_tim2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L10x_StdPeriph_Driver\src\stm8l10x_usart.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L10x_StdPeriph_Driver\inc\stm8l10x.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8l10x_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8l10x_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8l10x_it.h</name>
    </file>
  </group>
</project>


